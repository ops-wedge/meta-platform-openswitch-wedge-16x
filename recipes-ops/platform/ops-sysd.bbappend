# Copyright (C) 2016 Hewlett Packard Enterprise Development LP

PR_append = "_wedge-16x"

EXTRA_OECMAKE+="-DPLATFORM_WEDGE=ON"
